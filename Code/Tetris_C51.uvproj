# Keil uVision project Tetris_C51.uvproj, settings and files
target Target (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: Tetris_C51
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\inc
  group src
    ./src/: block.c delay.c display.c draw.c eeprom.c main.c menu.c mine.c
  group inc
    ./inc/: block.h button.h delay.h display.h draw.h eeprom.h img.h main.h menu.h mine.h
